# Keil uVision project Project.uvprojx, settings and files
target STM32L010RB_NUCLEO (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L010RBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20004FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L010xB,USE_FULL_LL_DRIVER
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../Drivers/STM32L0xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l010xb.s
  group Example/User
    ../Src/: main.c stm32l0xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Doc
    ../: readme.txt
  group Drivers/STM32L0xx_LL_Driver
    ../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_utils.c stm32l0xx_ll_dma.c stm32l0xx_ll_usart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_crc.c stm32l0xx_ll_spi.c stm32l0xx_ll_exti.c stm32l0xx_ll_rcc.c stm32l0xx_ll_gpio.c stm32l0xx_ll_lptim.c stm32l0xx_ll_i2c.c stm32l0xx_ll_rtc.c stm32l0xx_ll_adc.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_tim.c
software components: CMSIS:CORE 4.3.0
